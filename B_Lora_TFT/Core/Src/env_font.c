#include "env_font.h"
#include "tft.h"
#include "w25qxx.h"

#include <string.h>

#define ENV_FONT_MAGIC0 'E'
#define ENV_FONT_MAGIC1 'F'
#define ENV_FONT_MAGIC2 'N'
#define ENV_FONT_MAGIC3 'T'
#define ENV_FONT_VERSION 1U
#define ENV_FONT_COUNT 20U
#define ENV_FONT_HEADER_SIZE 16U
#define ENV_FONT_RECORD_SIZE (2U + ENV_FONT_GLYPH_BYTES)
#define ENV_FONT_SECTOR_SIZE 4096UL

typedef struct
{
  uint16_t codepoint;
  uint8_t glyph[ENV_FONT_GLYPH_BYTES];
} EnvFontBuiltinGlyph;

static const EnvFontBuiltinGlyph builtin_glyphs[ENV_FONT_COUNT] = {
  {0x663EU, {0x00, 0x00, 0x1F, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xF0, 0x04, 0x40, 0x44, 0x44, 0x24, 0x44, 0x14, 0x48, 0x14, 0x50, 0x04, 0x40, 0xFF, 0xFE, 0x00, 0x00}},
  {0x793AU, {0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0x00, 0x01, 0x00, 0x11, 0x10, 0x11, 0x08, 0x21, 0x04, 0x41, 0x02, 0x81, 0x02, 0x05, 0x00, 0x02, 0x00, 0x00, 0x00}},
  {0x5C4FU, {0x3F, 0xF8, 0x20, 0x08, 0x20, 0x08, 0x3F, 0xF8, 0x24, 0x10, 0x22, 0x20, 0x2F, 0xF8, 0x22, 0x20, 0x22, 0x20, 0x3F, 0xFC, 0x22, 0x20, 0x42, 0x20, 0x44, 0x20, 0x84, 0x20, 0x08, 0x20, 0x00, 0x00}},
  {0x521DU, {0x20, 0x00, 0x10, 0x00, 0x01, 0xFC, 0xFC, 0x44, 0x08, 0x44, 0x10, 0x44, 0x10, 0x44, 0x34, 0x44, 0x58, 0x44, 0x94, 0x44, 0x14, 0x44, 0x10, 0x84, 0x10, 0x84, 0x11, 0x04, 0x12, 0x28, 0x14, 0x10}},
  {0x59CBU, {0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0xFC, 0x48, 0x24, 0x84, 0x25, 0xFE, 0x24, 0x82, 0x24, 0x00, 0x48, 0xFC, 0x28, 0x84, 0x10, 0x84, 0x28, 0x84, 0x44, 0x84, 0x80, 0xFC, 0x00, 0x84}},
  {0x5316U, {0x08, 0x80, 0x08, 0x80, 0x08, 0x84, 0x10, 0x88, 0x10, 0x90, 0x30, 0xA0, 0x30, 0xC0, 0x50, 0x80, 0x91, 0x80, 0x12, 0x80, 0x14, 0x80, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x7E, 0x10, 0x00}},
  {0x4E2DU, {0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x3F, 0xF8, 0x21, 0x08, 0x21, 0x08, 0x21, 0x08, 0x21, 0x08, 0x21, 0x08, 0x3F, 0xF8, 0x21, 0x08, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00}},
  {0x73AFU, {0x00, 0x00, 0xFD, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x10, 0x20, 0x7C, 0x68, 0x10, 0xA4, 0x11, 0x22, 0x12, 0x22, 0x10, 0x20, 0x1C, 0x20, 0xE0, 0x20, 0x40, 0x20, 0x00, 0x20, 0x00, 0x00}},
  {0x5883U, {0x20, 0x80, 0x20, 0x40, 0x23, 0xF8, 0x21, 0x10, 0xF8, 0xA0, 0x27, 0xFE, 0x20, 0x00, 0x23, 0xF8, 0x22, 0x08, 0x23, 0xF8, 0x22, 0x08, 0x3B, 0xF8, 0xE1, 0x20, 0x41, 0x22, 0x02, 0x22, 0x0C, 0x1E}},
  {0x53C2U, {0x02, 0x00, 0x04, 0x40, 0x08, 0x20, 0x1F, 0xF0, 0x02, 0x00, 0x7F, 0xFC, 0x08, 0x20, 0x10, 0x90, 0x23, 0x08, 0xCC, 0x46, 0x01, 0x80, 0x06, 0x10, 0x18, 0x20, 0x00, 0xC0, 0x07, 0x00, 0x78, 0x00}},
  {0x6570U, {0x08, 0x20, 0x49, 0x20, 0x2A, 0x20, 0x08, 0x3E, 0xFF, 0x44, 0x2A, 0x44, 0x49, 0x44, 0x88, 0xA4, 0x10, 0x28, 0xFE, 0x28, 0x22, 0x10, 0x42, 0x10, 0x64, 0x28, 0x18, 0x28, 0x34, 0x44, 0xC2, 0x82}},
  {0x6E29U, {0x00, 0x00, 0x23, 0xF8, 0x12, 0x08, 0x12, 0x08, 0x83, 0xF8, 0x42, 0x08, 0x42, 0x08, 0x13, 0xF8, 0x10, 0x00, 0x27, 0xFC, 0xE4, 0xA4, 0x24, 0xA4, 0x24, 0xA4, 0x24, 0xA4, 0x2F, 0xFE, 0x00, 0x00}},
  {0x5EA6U, {0x01, 0x00, 0x00, 0x80, 0x3F, 0xFE, 0x22, 0x20, 0x22, 0x20, 0x3F, 0xFC, 0x22, 0x20, 0x22, 0x20, 0x23, 0xE0, 0x20, 0x00, 0x2F, 0xF0, 0x24, 0x10, 0x42, 0x20, 0x41, 0xC0, 0x86, 0x30, 0x38, 0x0E}},
  {0x6E7FU, {0x00, 0x00, 0x27, 0xF8, 0x14, 0x08, 0x14, 0x08, 0x87, 0xF8, 0x44, 0x08, 0x44, 0x08, 0x17, 0xF8, 0x11, 0x20, 0x21, 0x20, 0xE9, 0x24, 0x25, 0x28, 0x23, 0x30, 0x21, 0x20, 0x2F, 0xFE, 0x00, 0x00}},
  {0x4E8CU, {0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}},
  {0x6C27U, {0x20, 0x00, 0x3F, 0xFC, 0x40, 0x00, 0x9F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x11, 0x10, 0x0A, 0x10, 0x7F, 0xD0, 0x04, 0x10, 0x3F, 0x90, 0x04, 0x12, 0xFF, 0xEA, 0x04, 0x0A, 0x04, 0x06, 0x04, 0x02}},
  {0x78B3U, {0x00, 0x20, 0x01, 0x24, 0xF9, 0x24, 0x21, 0x24, 0x21, 0xFC, 0x40, 0x80, 0x78, 0x80, 0x4B, 0xFE, 0xC8, 0x90, 0x49, 0x10, 0x49, 0x52, 0x4A, 0x54, 0x7A, 0xA8, 0x4C, 0x28, 0x08, 0x44, 0x00, 0x82}},
  {0x6D53U, {0x00, 0x40, 0x20, 0x40, 0x10, 0x40, 0x17, 0xFC, 0x84, 0x84, 0x48, 0x88, 0x41, 0x40, 0x11, 0x44, 0x13, 0x48, 0x25, 0x30, 0xE9, 0x20, 0x21, 0x10, 0x21, 0x08, 0x21, 0x44, 0x21, 0x82, 0x01, 0x00}},
  {0x2103U, {0x60, 0x00, 0x91, 0xF4, 0x96, 0x0C, 0x6C, 0x04, 0x08, 0x04, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x04, 0x06, 0x08, 0x01, 0xF0, 0x00, 0x00}},
  {0xFF1AU, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}}
};

static const EnvFontBuiltinGlyph *find_builtin_glyph(uint16_t codepoint)
{
  for (uint8_t i = 0; i < ENV_FONT_COUNT; i++)
  {
    if (builtin_glyphs[i].codepoint == codepoint)
    {
      return &builtin_glyphs[i];
    }
  }

  return 0;
}

static void build_header(uint8_t header[ENV_FONT_HEADER_SIZE])
{
  memset(header, 0, ENV_FONT_HEADER_SIZE);
  header[0] = ENV_FONT_MAGIC0;
  header[1] = ENV_FONT_MAGIC1;
  header[2] = ENV_FONT_MAGIC2;
  header[3] = ENV_FONT_MAGIC3;
  header[4] = ENV_FONT_VERSION;
  header[5] = ENV_FONT_COUNT;
  header[6] = ENV_FONT_GLYPH_BYTES;
}

static uint8_t header_is_valid(const uint8_t header[ENV_FONT_HEADER_SIZE])
{
  return (uint8_t)((header[0] == ENV_FONT_MAGIC0) &&
                   (header[1] == ENV_FONT_MAGIC1) &&
                   (header[2] == ENV_FONT_MAGIC2) &&
                   (header[3] == ENV_FONT_MAGIC3) &&
                   (header[4] == ENV_FONT_VERSION) &&
                   (header[5] == ENV_FONT_COUNT) &&
                   (header[6] == ENV_FONT_GLYPH_BYTES));
}

static uint8_t program_bytes(uint32_t address, const uint8_t *data, uint16_t length)
{
  uint16_t written = 0;

  while (written < length)
  {
    uint16_t page_offset = (uint16_t)((address + written) & 0xFFU);
    uint16_t chunk = (uint16_t)(256U - page_offset);

    if (chunk > (uint16_t)(length - written))
    {
      chunk = (uint16_t)(length - written);
    }

    if (!W25QXX_PageProgram(address + written, &data[written], chunk))
    {
      return 0;
    }

    written = (uint16_t)(written + chunk);
  }

  return 1;
}

uint8_t EnvFont_InitStorage(void)
{
  uint8_t header[ENV_FONT_HEADER_SIZE];
  uint8_t record[ENV_FONT_RECORD_SIZE];
  uint8_t id[3];

  W25QXX_ReadID(id);
  if (!W25QXX_IsValidID(id))
  {
    return 0;
  }

  if (W25QXX_ReadData(ENV_FONT_ADDRESS, header, sizeof(header)) && header_is_valid(header))
  {
    return 1;
  }

  if (!W25QXX_SectorErase(ENV_FONT_ADDRESS))
  {
    return 0;
  }

  build_header(header);
  if (!program_bytes(ENV_FONT_ADDRESS, header, sizeof(header)))
  {
    return 0;
  }

  for (uint8_t i = 0; i < ENV_FONT_COUNT; i++)
  {
    uint32_t address = ENV_FONT_ADDRESS + ENV_FONT_HEADER_SIZE + ((uint32_t)i * ENV_FONT_RECORD_SIZE);
    record[0] = (uint8_t)builtin_glyphs[i].codepoint;
    record[1] = (uint8_t)(builtin_glyphs[i].codepoint >> 8);
    memcpy(&record[2], builtin_glyphs[i].glyph, ENV_FONT_GLYPH_BYTES);
    if (!program_bytes(address, record, sizeof(record)))
    {
      return 0;
    }
  }

  return 1;
}

uint8_t EnvFont_ReadGlyph(uint16_t codepoint, uint8_t glyph[ENV_FONT_GLYPH_BYTES])
{
  uint8_t header[ENV_FONT_HEADER_SIZE];
  uint8_t record[ENV_FONT_RECORD_SIZE];
  const EnvFontBuiltinGlyph *fallback;

  if (glyph == 0)
  {
    return 0;
  }

  if (W25QXX_ReadData(ENV_FONT_ADDRESS, header, sizeof(header)) && header_is_valid(header))
  {
    for (uint8_t i = 0; i < ENV_FONT_COUNT; i++)
    {
      uint32_t address = ENV_FONT_ADDRESS + ENV_FONT_HEADER_SIZE + ((uint32_t)i * ENV_FONT_RECORD_SIZE);
      uint16_t stored_codepoint;

      if (!W25QXX_ReadData(address, record, sizeof(record)))
      {
        break;
      }

      stored_codepoint = (uint16_t)record[0] | ((uint16_t)record[1] << 8);
      if (stored_codepoint == codepoint)
      {
        memcpy(glyph, &record[2], ENV_FONT_GLYPH_BYTES);
        return 1;
      }
    }
  }

  fallback = find_builtin_glyph(codepoint);
  if (fallback != 0)
  {
    memcpy(glyph, fallback->glyph, ENV_FONT_GLYPH_BYTES);
    return 1;
  }

  return 0;
}

void EnvFont_DrawGlyph(uint16_t x, uint16_t y, uint16_t codepoint, uint16_t color, uint16_t bg)
{
  uint8_t glyph[ENV_FONT_GLYPH_BYTES];

  if (!EnvFont_ReadGlyph(codepoint, glyph))
  {
    TFT_FillRect(x, y, ENV_FONT_GLYPH_WIDTH, ENV_FONT_GLYPH_HEIGHT, bg);
    return;
  }

  for (uint8_t row = 0; row < ENV_FONT_GLYPH_HEIGHT; row++)
  {
    uint8_t left = glyph[row * 2U];
    uint8_t right = glyph[(row * 2U) + 1U];

    for (uint8_t col = 0; col < 8U; col++)
    {
      uint16_t pixel_color = (left & (uint8_t)(0x80U >> col)) ? color : bg;
      TFT_DrawPixel((uint16_t)(x + col), (uint16_t)(y + row), pixel_color);
    }
    for (uint8_t col = 0; col < 8U; col++)
    {
      uint16_t pixel_color = (right & (uint8_t)(0x80U >> col)) ? color : bg;
      TFT_DrawPixel((uint16_t)(x + 8U + col), (uint16_t)(y + row), pixel_color);
    }
  }
}

void EnvFont_DrawText(uint16_t x, uint16_t y, const uint16_t *text, uint8_t count,
                      uint16_t color, uint16_t bg)
{
  if (text == 0)
  {
    return;
  }

  for (uint8_t i = 0; i < count; i++)
  {
    EnvFont_DrawGlyph((uint16_t)(x + ((uint16_t)i * ENV_FONT_GLYPH_WIDTH)),
                      y, text[i], color, bg);
  }
}
